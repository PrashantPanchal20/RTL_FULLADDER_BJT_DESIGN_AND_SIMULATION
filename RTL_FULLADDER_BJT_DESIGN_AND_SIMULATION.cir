* C:\Users\lenovo\eSim-Workspace\RTL_FULL_ADDER_DESIGN_AND_SIMULATION\RTL_FULL_ADDER_DESIGN_AND_SIMULATION.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/04/21 20:02:05

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
Q1  Net-_Q1-Pad1_ Net-_Q1-Pad2_ GND NPN
R2  Va Net-_Q1-Pad2_ 10K
R1  Vb Net-_Q1-Pad2_ 10K
R3  Net-_Q1-Pad1_ Net-_R12-Pad2_ 1K
Q3  Net-_Q3-Pad1_ Net-_Q3-Pad2_ GND NPN
R8  Net-_Q1-Pad1_ Net-_Q3-Pad2_ 10K
R7  Vb Net-_Q3-Pad2_ 10K
R9  Net-_Q3-Pad1_ Net-_R12-Pad2_ 1K
Q2  Net-_Q2-Pad1_ Net-_Q2-Pad2_ GND NPN
R5  Va Net-_Q2-Pad2_ 10K
R4  Net-_Q1-Pad1_ Net-_Q2-Pad2_ 10K
R6  Net-_Q2-Pad1_ Net-_R12-Pad2_ 1K
Q4  Net-_Q4-Pad1_ Net-_Q4-Pad2_ GND NPN
R11  Net-_Q2-Pad1_ Net-_Q4-Pad2_ 10K
R10  Net-_Q3-Pad1_ Net-_Q4-Pad2_ 10K
R12  Net-_Q4-Pad1_ Net-_R12-Pad2_ 1K
Q5  Net-_Q5-Pad1_ Net-_Q5-Pad2_ GND NPN
R14  Net-_Q4-Pad1_ Net-_Q5-Pad2_ 10K
R13  Vc Net-_Q5-Pad2_ 10K
R15  Net-_Q5-Pad1_ Net-_R12-Pad2_ 1K
Q6  Net-_Q6-Pad1_ Net-_Q6-Pad2_ GND NPN
R17  Net-_Q4-Pad1_ Net-_Q6-Pad2_ 10K
R16  Net-_Q5-Pad1_ Net-_Q6-Pad2_ 10K
R18  Net-_Q6-Pad1_ Net-_R12-Pad2_ 1K
Q7  Net-_Q7-Pad1_ Net-_Q7-Pad2_ GND NPN
R20  Net-_Q5-Pad1_ Net-_Q7-Pad2_ 10K
R19  Vc Net-_Q7-Pad2_ 10K
R21  Net-_Q7-Pad1_ Net-_R12-Pad2_ 1K
Q8  SUM Net-_Q8-Pad2_ GND NPN
R23  Net-_Q6-Pad1_ Net-_Q8-Pad2_ 10K
R22  Net-_Q7-Pad1_ Net-_Q8-Pad2_ 10K
R24  SUM Net-_R12-Pad2_ 1K
Q9  CARRY Net-_Q9-Pad2_ GND NPN
R26  Net-_Q5-Pad1_ Net-_Q9-Pad2_ 10K
R25  Net-_Q1-Pad1_ Net-_Q9-Pad2_ 10K
R27  CARRY Net-_R12-Pad2_ 1K
v4  Net-_R12-Pad2_ GND DC
v1  Va GND pulse
v2  Vb GND pulse
v3  Vc GND pulse
U1  Va plot_v1
U2  Vb plot_v1
U3  Vc plot_v1
U4  SUM plot_v1
U5  CARRY plot_v1

.end
